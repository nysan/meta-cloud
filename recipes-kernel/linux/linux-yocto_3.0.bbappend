linux-yocto_3.4.bbappend